Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 2cf2a163-5c4a-462d-80c6-14deaa25503c.ifc
Time: 2026-08-11T11:17:38
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-THERMO 110, 1000x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAAHc6h8IGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAIesCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAHc6h8IGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAIesCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 45 kg/st; STABU2: 43.31.10; lengte: 1135 mm; dagmaatlengte: 1000 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1135 mm; Rc-waarde: 4 m²·k/w; type: 110; serie: BV-THERMO; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; dagmaatbreedte: 1000 mm; omranding: staal; luik: luik element luikpaneel geïsoleerd Storax
