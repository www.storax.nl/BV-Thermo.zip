Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 4ce7eedf-d53c-45b9-914a-d3f92221716f.ifc
Time: 2026-08-11T11:16:09
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-THERMO 55, 500x500mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAAHcigMIGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAOewCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAHcigMIGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAOewCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 19 kg/st; STABU2: 43.31.10; lengte: 635 mm; dagmaatlengte: 500 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 635 mm; Rc-waarde: 4 m²·k/w; type: 55; serie: BV-THERMO; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; dagmaatbreedte: 500 mm; omranding: staal; luik: luik element luikpaneel geïsoleerd Storax
