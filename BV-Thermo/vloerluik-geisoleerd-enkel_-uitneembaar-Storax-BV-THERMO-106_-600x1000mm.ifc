Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: a81d383a-574c-44f4-91e5-edf44a1ae559.ifc
Time: 2026-08-11T11:17:24
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-THERMO 106, 600x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAAHeuh8IGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAtesCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAHeuh8IGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAtesCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 33 kg/st; STABU2: 43.31.10; lengte: 735 mm; dagmaatlengte: 600 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1135 mm; Rc-waarde: 4 m²·k/w; type: 106; serie: BV-THERMO; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; dagmaatbreedte: 1000 mm; omranding: staal; luik: luik element luikpaneel geïsoleerd Storax
