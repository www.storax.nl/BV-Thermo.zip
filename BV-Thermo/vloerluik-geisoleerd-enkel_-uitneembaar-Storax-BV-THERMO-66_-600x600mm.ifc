Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 4d2d04d2-c566-411c-9d23-6898d04894fc.ifc
Time: 2026-08-11T11:16:35
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik geïsoleerd enkel, uitneembaar Storax - BV-THERMO 66, 600x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 4 m²·k/w
Pset_Data - WUID: AgAAAHe4h8IGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAo-sCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAHe4h8IGAAAAguwCAAV2SgAAJVQBAFJfAQAV6wIAo-sCAAIA6gcBAQAAAAEAAADlBwEBAAAABQAAAMypAQAFBv4AAMcMAgC7cwAAm6cBAP-mAQADACoAAQEAAAACAAAADAABAQAAAAMAAAC5AgEBAAAABAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAIpqAAAFZ90AAGQwAADGpwAAo60AAIkwAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 23 kg/st; STABU2: 43.31.10; lengte: 735 mm; dagmaatlengte: 600 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 735 mm; Rc-waarde: 4 m²·k/w; type: 66; serie: BV-THERMO; afsluitbaar: True; hoogte: 75 mm; merk: Storax; breuklast: B125; dagmaatbreedte: 600 mm; omranding: staal; luik: luik element luikpaneel geïsoleerd Storax
